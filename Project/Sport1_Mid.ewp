# IAR project Sport1_Mid.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\App; ..\CMSIS\CM3\CoreSupport; ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Driver_St\inc; ..\Driver_User\inc; ..\Startup; ..\Utilities; ..\Common; ..\Mid\inc; ..\Mid\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sport1_Mid.srec
  ILINK.IlinkOutputFile: Sport1_Mid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: main.c
  group CMSIS/CoreSupport
    ../CMSIS/CM3/CoreSupport/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group CMSIS/DeviceSupport
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Common
    ../Common/: common.h
  group Driver_St/inc
    ../Driver_St/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Driver_St/src
    ../Driver_St/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Driver_User/keypad
    ../Driver_User/src/: keypad.c
    ../Driver_User/inc/: keypad.h
  group Driver_User/systick
    ../Driver_User/src/: systick.c
    ../Driver_User/inc/: systick.h
  group Mid
    ../Mid/src/: exercise_mode.c run_mode.c setup_mode.c
    ../Mid/inc/: exercise_mode.h run_mode.h setup_mode.h
  group Startup
    ../Startup/: startup_stm32f10x_md.s stm32f10x_conf.h stm32f10x_it.h
  group Utilities
    ../Utilities/: debug.c debug.h queue.c queue.h xor.c xor.h
